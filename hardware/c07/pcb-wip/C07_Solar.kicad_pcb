# Repository MahleCube/solar-circuit

File README.md:

# 太陽光充電システム

この制作はオフグリッド用太陽光発電システムの設計のポートフォリオです。  
シミュレーションでのみ動作の確認を行っており実機の作成まで行っていません。

- 400ｗのパネルを二枚直列に繋いだ800ｗの充電システムです。
- バッテリーには51.2Vのリン酸鉄リチウムイオンバッテリーを採用しています。
- HIGH側、LOW側にNchMOSFetを設置した同期整流、BUCK方式です。
- 保護ICによるハードウェア保護回路をパネル側バッテリー側両側に使用

ソーラーパネルから制御回路を通ってバッテリーに充電するまでの部分の制作です。
制御回路からバッテリーを介さず電力を消費するパススルー機能や
バッテリーから電力をACで取り出すインバーターは含まれません。

## プログラムの効率

- MPP追従性能　**99%前後**
- 日射量が0.03秒ごとに急変する状況で　**96,977％**

## 回路の効率

- 750w時　95.7%
- 600w時　96.1%
- **300w時　96.5%**
- 100w時　94.0%
- 50w時　90.0%
- *10w時 63.0%　発電量が少ない時に急激に効率が下がる*

---

2023年　京都市南区の特定地点での放射照度から計算する

- パネルから取り出せる理論上最大電力量は　**1,309kWh**
- 年間の放射照度を1時間ごとに効率計算を行った発電量　**1,248.9kWh**

**→年間の効率期待値　95.4%**

ただし、今回は用途を指定していない。  
全ての充電電力を一度バッテリーに入れてからAC電力として取り出す場合の電力量は  
バッテリーの充放電効率とAC変換効率をかける必要がある。

> ACで使える電力量 = バッテリーへの充電電力量　×　充放電効率 × AC変換効率

今回の回路では電気を取り出す仕組みまでは作成していないので暫定的に以下のようにありそうな値を代入して計算を行う。

- 充放電効率 92%
- AC変換効率　94%　と仮定する。

**1,248 × 0.92 × 0.94 = 大体1,079kWh / 年**

---

設計した充電システムの実用性を検討するため、年間充電量と機器費用から経済性も概算しました。

**2026年11月7日時点の流通価格にて計算**

- 回路価格　87,060円
- 400Wソーラーパネル　62,100円×2
- 51,2V 100Ahリチウムイオンバッテリー　118,181円

**合計　329,441円**

電力の料金は会社やプランによって変動があるが関西電力の各種プランの中間程度の価格  
23円/kWhと仮置きすると年間**24840円/年**

無駄なく電気を消費したとして制作費を回収できるまでの期間は**13年3ヶ月**となる。

この試算から、経済性を検討するのであれば、回路効率に加えて、使用する機器、消費する時間帯、必要な蓄電池容量まで含めて設計する必要があると考えられます。

## 掲載資料

- [部品表（Excel）](docs/bom/c07_BOM.xlsx)
- [回路図（PDF・3ページ）](docs/schematic/C07_Solar.pdf)
- [KiCad回路図データ](hardware/c07/pcb-wip/)
- [KiCad PCBデータ](hardware/c07/pcb-wip/)
- [制御コード（C）](firmware/r04/)
- [MATLAB回路図データ](hardware/c07/matlab/)

## KiCad design hardware/c07/pcb-wip/C07_Solar.kicad_pcb

File hardware/c07/pcb-wip/README.md:

# C07 PCB

r26（2026-11-06）。264 × 136 mm、6層の配置・配線を仕上げた設計版です。Pico Wの交換式ソケット、IC端子間を迂回する配線、M3用取付穴4か所を反映しています。

KiCad 10で `C07_Solar.kicad_pro` を開き、PCB Editorで `C07_Solar.kicad_pcb` を開いてください。対応する回路図、カスタムライブラリ、プロジェクト内3Dモデルを同梱しています。KiCad 10の標準フットプリント・3Dモデルライブラリも必要です。

実機製作・性能検証・製造承認は未実施です。放熱器と絶縁・固定具、外部線材と保持、筐体支持、製造公差などの条件は未確定です。

ライブラリ・3Dモデルの帰属と利用条件は [LICENSES](LICENSES/) および各ファイルのヘッダ、同梱メーカー免責文を参照してください。

Schematic: C07_Solar.kicad_sch

Parts:
BT1: 51.2V 100Ah LiFePO4; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm_C07Reference; MPN LiTime 51.2V 100Ah
C1: 22 nF; C_TDK_C3225_H230; MPN C3225C0G2J223J230AA
C2, C3, C4: 470 uF; CP_Radial_D18.0mm_P7.50mm; MPN UCY2C471MHD
C7: 3.3 uF; KEMET_R76_P27p5_32x18; MPN R76IR433050H3J
C8, C9, C10: 2.2 uF; C_TDK_C5750_H250; MPN C5750X7T2E225K250KE
C13, C14: 470 uF; CP_Radial_D16.0mm_P7.50mm; MPN 100ZLH470MEFC16X31.5
C15, C16: 10 uF; C_Murata_GRM32_H250; MPN GRM32EC72A106KE05L
C17: 100 nF; C_KEMET_C0805_H078; MPN C0805C104K4RACTU
C18: 2.2 uF; C_TDK_C3225_H230; MPN C3225X7R2A225K230AB
C19, C20, C21, C23, C25, C26, C28: 100 nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104
C24: 100 nF; C_TDK_C1608_H080; MPN C1608X7R1H104K080AA
C27, C29: 680 pF; C_0603_1608Metric; MPN AC0603JPNPO9BN681
C30, C31: 1 uF; C_TDK_C2012_H125; MPN C2012X7R1H105K125AB
C32, C33, C47: 1 uF; C_Murata_GRM21_H125; MPN GRM21BR71H105KA12L
C34, C35, C37, C45, C48: 22 uF; C_Murata_GRM32_H250; MPN GRM32ER71E226KE15L
C36, C38: 100 nF; C_Murata_GRM21_H125; MPN GRM21BR71H104KA01L
C39: 330 pF; C_KEMET_C0805_H078; MPN C0805C331J5GACTU
C40, C41, C42, C43, C44: 2.2 uF; C_KEMET_FT1210_H210; MPN C1210X225K1RACAUTO
C46: 470 uF; Panasonic_EEHZK1E471P; MPN EEHZK1E471P
D1, D2: BZT52H-C15,115; Nexperia_SOD123F; MPN BZT52H-C15,115
D3: SS14-E3/61T; D_SMA; MPN SS14-E3/61T
F1: 1.6A 300VDC; SCHURTER_SMD_SPT_5x20; MPN 0001.2706.11
F2: 20A gPV; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm_C07Reference; MPN HP10M20
F3: 25ADC; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm_C07Reference; MPN LP-CC-25
F4: 3.2ADC; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm_C07Reference; MPN LP-CC-3-2/10
J_PV1: PV INPUT +/-; SolderWire-1sqmm_1x02_P5.4mm_D1.4mm_OD2.7mm_C07Reference; MPN UNSELECTED
L1: 200 uH; Tamura_NAC20_0201_No265_FormedLeads_4x2; MPN NAC-20-0201
PV_C101: 100 nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104
PV_R101: 3.3 kOhm; R_Susumu_RG2012_H040; MPN RG2012P-332-B-T5
PV_RV_H1, PV_RV_H2: 75 kOhm; R_Susumu_RG2012_H040; MPN RG2012P-753-B-T5
Q1, Q2: TK9R6E15Q5,S1X; TO-220-3_Vertical; MPN TK9R6E15Q5,S1X
Q3: PMGD175XNEX; Nexperia_SOT363_3; MPN PMGD175XNEX
R1: 15 kOhm; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal; MPN PR02000201502FA100
R2: 1 mOhm / Kelvin; Bourns_CSS4J_4026R_1L00F_Kelvin; MPN CSS4J-4026R-1L00F
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: 4.42 Ohm; R_Vishay_CRCW2512_HP; MPN CRCW25124R42FKEGHP
R15: 10 kOhm; R_Yageo_RC0603_H045; MPN RC0603FR-0710KL
R16, R17, R19, R20, R22, R23: 75 kOhm; R_Susumu_RG2012_H040; MPN RG2012P-753-B-T5
R18, R21, R24: 3.3 kOhm; R_Susumu_RG2012_H040; MPN RG2012P-332-B-T5
R25, R26: 100 Ohm; R_Susumu_RG2012_H040; MPN RG2012P-101-B-T5
R28, R29: 47 Ohm; R_Susumu_RG2012_H040; MPN RG2012P-470-B-T5
R30: 100 mOhm; R_Panasonic_ERJ3RS_H045; MPN ERJ3RSFR10V
R31, R38: 232 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF2320V
R32, R39: 154 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1540V
R33, R40: 20 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF2002V
R34, R41: 330 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF3300V
R35, R37, R42, R44, R46, R48, R49: 10 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1002V
R36, R43: 10 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF10R0V
R45: 38.3 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF3832V
R47: 0 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6GEY0R00V
U1: MCP3208-CI/SL; SOIC-16_3.9x9.9mm_P1.27mm; MPN MCP3208-CI/SL
U3: INA241A3IDDFR; TI_DDF0008A_SOT-23-8_1.6x2.9mm_P0.65mm; MPN INA241A3IDDFR
U4, U5: TMP235A2DBZR; TI_DBZ0003A; MPN TMP235A2DBZR
U6: REF3025EAIDBZR; TI_DBZ0003A; MPN REF3025EAIDBZR
U7: SC0918; Pico_W_SocketPair_SSQ_1x20_17.78; MPN SC0918
U8, U9: ACPL-P346-560E; Broadcom_ACPL-P346_SSO-6; MPN ACPL-P346-560E
U10: UCC14131QDWNRQ1; TI_DWN0036A_SSOP-36_7.6x12.93mm_P0.65mm; MPN UCC14131QDWNRQ1
U11: TSR 1-48120WI; Traco_TSR1WI_vertical_5pin; MPN TSR 1-48120WI
U12: TSR 1-2450; Converter_DCDC_TRACO_TSR-1_THT; MPN TSR 1-2450

Connections:
ADC_IL: C25.1, R26.2, U1.4 (CH3)
ADC_IPV: C23.1, R25.2, U1.2 (CH1)
ADC_TBAT: C27.1, R28.2, U1.5 (CH4)
ADC_TSINK: C29.1, R29.2, U1.6 (CH5)
ADC_VBAT: C21.1, R23.2, R24.1, U1.7 (CH6)
ADC_VOUT: C20.1, R20.2, R21.1, U1.3 (CH2)
ADC_VPV: C19.1, R17.2, R18.1, U1.1 (CH0)
ADC_VPV_INPUT: PV_C101.1, PV_R101.1, PV_RV_H2.2, U1.8 (CH7)
BAT_AUX: C40.1, C41.1, C42.1, C43.1, C44.1, F1.2, U11.1 (+VIN)
BAT_FUSE_MID: F1.1, F4.2
BAT_PLUS: F3.2, R22.1; also elsewhere on the board
BAT_RAW: BT1.1 (+), F3.1, F4.1
BIAS_EN: R48.1, U7.11 (GP8), U10.4 (ENA)
BIAS_PG: R49.1, U7.12 (GP9), U10.3 (PG)
BUCK_SW_HS_RETURN: C32.2, C37.2, C38.2, C39.2, D1.2 (A), L1.1, Q1.3 (S), Q2.2 (D), R3.1, R5.1, R7.1, R9.1, R11.1, R13.1, R37.2, R46.2, U8.4 (VEE), U10.19 (VEE), U10.20 (VEE), U10.21 (VEE), U10.22 (VEE), U10.23 (VEE), U10.24 (VEE), U10.25 (VEE), U10.26 (VEE), U10.27 (VEE), U10.30 (VEE), U10.31 (VEE), U10.35 (VEEA), U10.36 (VEE)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, D2.2 (A), J_PV1.2, PV_C101.2, PV_R101.2, Q2.3 (S), Q3.1 (S1), Q3.4 (S2), R1.2, R18.2, R21.2, R24.2, R35.2, R42.2, R44.2, R48.2, U1.9 (DGND), U1.14 (AGND), U3.2 (GND), U3.3 (REF2), U3.4 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U7.8 (GND), U7.13 (GND), U7.18 (GND), U7.23 (GND), U7.28 (GND), U7.33 (AGND), U7.38 (GND), U9.2 (NC), U9.4 (VEE), U10.1 (GNDP), U10.2 (GNDP), U10.5 (GNDP), U10.8 (GNDP), U10.9 (GNDP), U10.10 (GNDP), U10.11 (GNDP)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; also elsewhere on the board
GP6: R34.1, U7.9 (GP6)
GP7: R41.1, U7.10 (GP7)
H12: C32.1, C37.1, C38.1, R45.1, R47.2, U8.6 (VCC), U10.28 (VDD), U10.29 (VDD)
HS_BIAS_RLIM: R47.1, U10.32 (RLIM)
HS_DRIVER_OUT: R36.1, U8.5 (VOUT)
HS_GATE: D1.1 (K), Q1.1 (G), R36.2, R37.1
HS_LED_ANODE: R31.2, R33.1, U8.1 (ANODE)
HS_LED_CATHODE: R32.1, R33.2, U8.3 (CATHODE)
HS_LED_GATE: Q3.2 (G1), R34.2, R35.1
HS_LED_SINK: Q3.6 (D1), R32.2
H_FB: C39.1, R45.2, R46.1, U10.33 (FBVEE), U10.34 (FBVDD)
IL_AMP_OUT: R26.1, U3.5
IL_SENSE_M: C13.1, C14.1, C15.1, C16.1, R2.IM, R2.KM, R19.1, U3.1 (-); also elsewhere on the board
IL_SENSE_P: L1.2, R2.IP, R2.KP, U3.8 (+)
IPV_OUT: R25.1; also elsewhere on the board
LS_DRIVER_OUT: R43.1, U9.5 (VOUT)
LS_GATE: D2.1 (K), Q2.1 (G), R43.2, R44.1
LS_LED_ANODE: R38.2, R40.1, U9.1 (ANODE)
LS_LED_CATHODE: R39.1, R40.2, U9.3 (CATHODE)
LS_LED_GATE: Q3.5 (G2), R41.2, R42.1
LS_LED_SINK: Q3.3 (D2), R39.2
MAIN_EN: U7.15 (GP11); also elsewhere on the board
P5: C48.1, D3.2 (A), R31.1, R38.1, U12.3 (Vout)
P12: C33.1, C34.1, C35.1, C36.1, C45.1, C46.1, C47.1, U9.6 (VCC), U10.6 (VIN), U10.7 (VIN), U11.3 (+VOUT), U12.1 (Vin)
PROTECTION_FLT_N: U7.17 (GP13); also elsewhere on the board
PV_FUSED: F2.2, PV_RV_H1.1; also elsewhere on the board
PV_INPUT_DIV_MID: PV_RV_H1.2, PV_RV_H2.1
PV_MCU_REARM: U7.16 (GP12); also elsewhere on the board
PV_MCU_RUN: U7.14 (GP10); also elsewhere on the board
PV_OC_FAULT_N: U7.19 (GP14); also elsewhere on the board
PV_STOPPED: U7.20 (GP15); also elsewhere on the board
PV_STRING_POS: F2.1, J_PV1.1
SNUB_R3_R4_MID: R3.2, R4.1
SNUB_R5_R6_MID: R5.2, R6.1
SNUB_R7_R8_MID: R7.2, R8.1
SNUB_R9_R10_MID: R9.2, R10.1
SNUB_R11_R12_MID: R11.2, R12.1
SNUB_R13_R14_MID: R13.2, R14.1
SPI_CS_N: R15.2, U1.10 (~CS/SHDN), U7.22 (GP17)
SPI_MISO: U1.12 (Dout), U7.21 (GP16)
SPI_MOSI: U1.11 (Din), U7.25 (GP19)
SPI_SCK: U1.13 (CLK), U7.24 (GP18)
SW_SNUBBER_RC: C1.1, R4.2, R6.2, R8.2, R10.2, R12.2, R14.2
TBAT_SENSOR_OUT: R28.1, U4.2 (OUT)
TSINK_SENSOR_OUT: R29.1, U5.2 (OUT)
V3V3: C17.1, C18.1, C24.1, C26.1, C28.1, C30.1, R15.1, R49.2, U1.16 (Vdd), U3.6 (V+), U4.1 (VDD), U5.1 (VDD), U6.1 (IN), U7.36 (3V3_OUT); also elsewhere on the board
VBAT_DIV_MID: R22.2, R23.1
VIN: C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, Q1.2 (D), R1.1, R16.1; also elsewhere on the board
VIN_DIV_MID: R16.2, R17.1
VOUT_DIV_MID: R19.2, R20.1
VREF2V5_ADC: R30.1, U1.15 (Vref), U3.7 (REF1), U6.2 (OUT); also elsewhere on the board
VREF_DECOUPLE: C31.1, R30.2
VSYS_5V: D3.1 (K), U7.39 (VSYS)

Notes on the sheet:
バッテリ補助電源（ヒューズ後）
電源の補足：小さな旗は各供給点へ移設済み
PV入力（ヒューズ後）
ERC power declarations: verified sources via passive paths. BAT_AUX: BT1 -> F4 -> F1; VSYS_5V: U11 -> U12 -> D3. GND: common battery return. Flags are not extra supplies.
C07 MATLAB schematic transfer Layout and connectivity extracted independently. Nearby connections use wires; distant connections use global labels. Footprints and 3D models are not fabrication-qualified. Original MATLAB identifiers are stored in component properties.
バッテリー負極・共通GND
Pico用5V（逆流防止後）

Parts:
P_C101: 47 nF; C_TDK_C3225_H250; MPN CGA6P3C0G2E473J250AA
P_C102: 330 uF; CP_Radial_D12.5mm_P5.00mm; MPN 100ZLH330MEFC12.5X35
P_C103: 100 nF; C_TDK_C3216_H160; MPN CGA5L2C0G1H104J160AE
P_D1: 68 V; D_SMA; MPN CMZ5945B TR13 PBFREE
P_D6, P_D7: 15 V; D_SOD-523; MPN DDZ9702T
P_Q1: IPB048N15N5LFATMA1; TO-263-2; MPN IPB048N15N5LFATMA1
P_Q2: 150V / 4.8mOhm max at25C10V; TO-263-2; MPN IPB048N15N5LFATMA1
P_R1: 243 kOhm; R_Vishay_TNPW0805; MPN TNPW0805243KBEEA
P_R2: 2.74 kOhm; R_Vishay_TNPW0805; MPN TNPW08052K74BEEA
P_R3, P_R8: 4.99 kOhm; R_Vishay_TNPW0805; MPN TNPW08054K99BEEA
P_R4: 6.8 kOhm; R_Vishay_CRCW2512_H060; MPN CRCW25126K80FKEG
P_R5: 10 Ohm; R_Vishay_CRCW0805_H050; MPN CRCW080510R0FKEA
P_R7: 236 kOhm; R_Vishay_TNPW0805; MPN TNPW0805236KBEEA
P_R101: 2.7 mOhm; WSL3637_2m_to_10m_Kelvin; MPN WSL36372L700FEA
P_R102: 1 kOhm; R_Vishay_CRCW0805_H050; MPN CRCW08051K00FKEA
P_R103: 22 kOhm; R_Vishay_CRCW0805_H050; MPN CRCW080522K0FKEA
P_R104: 47 kOhm; R_Vishay_CRCW0805_H050; MPN CRCW080547K0FKEA
P_U1: LTC4364IMS-1#PBF; MSOP-16_3x4.039mm_P0.5mm; MPN LTC4364IMS-1#PBF

Connections:
/LTC4364_Protection/P_KELVIN_OUT: P_R101.E2, P_U1.1 (OUT)
/LTC4364_Protection/P_KELVIN_SENSE: P_R101.E1, P_U1.2 (SENSE)
BAT_PLUS: P_C102.1, P_R7.1, P_R101.I2; also elsewhere on the board
ENOUT: P_U1.14 (ENOUT)
GND: P_C101.2, P_C102.2, P_C103.2, P_D1.2 (A), P_R3.2, P_R8.2, P_R104.2, P_U1.12 (GND); also elsewhere on the board
IL_SENSE_M: P_Q1.2 (D), P_R1.1, P_R4.1; also elsewhere on the board
MAIN_EN: P_R102.1; also elsewhere on the board
PROTECTION_FLT_N: P_R103.2, P_U1.13 (~FLT); also elsewhere on the board
PROT_DGATE: P_D7.1 (K), P_Q2.1 (G), P_U1.4 (DGATE)
PROT_FB_SENSE: P_R7.2, P_R8.1, P_U1.16 (FB)
PROT_FET_SOURCE: P_D6.2 (A), P_D7.2 (A), P_Q1.3 (S), P_Q2.3 (S), P_U1.5 (SOURCE)
PROT_HGATE_DRV: P_C101.1, P_D6.1 (K), P_R5.1, P_U1.6 (HGATE)
PROT_IC_VCC: P_D1.1 (K), P_R4.2, P_U1.8 (VCC)
PROT_OV_SENSE: P_R2.2, P_R3.1, P_U1.11 (OV)
PROT_Q1_GATE: P_Q1.1 (G), P_R5.2
PROT_SHDN_N: P_R102.2, P_R104.1, P_U1.9 (~SHDN)
PROT_SHUNT_IN: P_Q2.2 (D), P_R101.I1
PROT_TIMER: P_C103.1, P_U1.15 (TMR)
PROT_UV_SENSE: P_R1.2, P_R2.1, P_U1.10 (UV)
V3V3: P_R103.1; also elsewhere on the board

Notes on the sheet:
WSL3637: I1/I2 = current; E1/E2 = dedicated Kelvin sense. Do not merge sense traces into the load-current copper. I/E names follow datasheet p2; footprint mapping is pending.
保護IC用電源（P_R4後）
旧原本についての説明（下記）／現図は4端子へ修正済み 現在のP_R101：I1・I2は主電流、E1・E2は専用検出線。 フットプリントは未確定。ENOUTは未使用。
供給の補足：旗はP_R4後の配線上へ移設済み
SOURCE MODEL VIEW - WSL3637 (P_R101) is a two-terminal representation. Physical part has four terminals; Kelvin wiring and footprint remain unqualified. ENOUT is left open in the source model.
ERC: PROT_IC_VCC supplied from VIN via P_R4. ENOUT is unused (LTC4364 datasheet p9).

Parts:
C22: 100 nF; C_TDK_C1608_H080; MPN C1608X7R1H104K080AA
L2: 62 uH; Wuerth_WE-HCFT_74437636356203; MPN 74437636356203
PV_C102: 10 uF; C_Murata_GRM32_H250; MPN GRM32EC72A106KE05L
PV_C103: 10 nF; C_TDK_C2012_H060; MPN C2012C0G1H103J060AA
PV_C104: 1 nF; C_TDK_C2012_H060; MPN C2012C0G1H102J060AA
PV_C105: 1 uF; C_TDK_C2012_H125; MPN C2012X7R1H105K125AB
PV_C106, PV_C107: 100 nF; C_TDK_C4532_H320; MPN C4532C0G2E104J320KN
PV_C108: 100 nF; C_Murata_GRM21_H125; MPN GRM21BR71H104KA01L
PV_C_PV_U3, PV_C_PV_U4, PV_C_PV_U5: 100 nF; C_Murata_GRM21_H125; MPN GRM21BR71H104KA01L
PV_D101: MMBD1501A; SOT-23; MPN MMBD1501A
PV_D102, PV_D104, PV_D105: V20PW22-M3/I; Vishay_V20PW22_SlimDPAK_TO-252AE_K12; MPN V20PW22-M3/I
PV_D103: BZT52H-C15,115; Nexperia_SOD123F; MPN BZT52H-C15,115
PV_Q1, PV_Q2: IPB048N15N5LFATMA1; TO-263-2; MPN IPB048N15N5LFATMA1
PV_R102, PV_R105, PV_R107, PV_R110, PV_R113, PV_R114: 100 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1003V
PV_R103: 100 Ohm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1000V
PV_R104: 22 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF2202V
PV_R106: 10 MOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6GEYJ106V
PV_R108: 820 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF8203V
PV_R109, PV_R119: 10 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1002V
PV_R111: 10.2 kOhm; R_Panasonic_ERA6A_2012; MPN ERA6AEB1022V
PV_R112: 9.8 kOhm; R_VPG_FRSM0805_Hmax064; MPN Y40229K80000B9R
PV_R115: 330 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF3303V
PV_R116: 10.2 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1022V
PV_R117: 113 kOhm; R_Panasonic_ERJ6E_2012; MPN ERJ6ENF1133V
PV_R118: 10 Ohm; R_Vishay_CRCW2512_HP; MPN CRCW251210R0FKEGHP
PV_R_SUP25: 21.3 kOhm; R_Vishay_TNPW0805; MPN TNPW080521K3BEEA
PV_R_SUP26, PV_R_SUP32: 10 kOhm; R_Vishay_TNPW0805; MPN TNPW080510K0BEEA
PV_R_SUP31: 31.2 kOhm; R_Vishay_TNPW0805; MPN TNPW080531K2BEEA
PV_U1: LTC7000ARMSE#PBF; MSOP-16-1EP_3x4.039mm_P0.5mm_EP1.651x2.845mm; MPN LTC7000ARMSE#PBF
PV_U3: TLV3201AIDBVR; TI_DBV0005A; MPN TLV3201AIDBVR
PV_U4: SN74LVC1G11DBVR; TI_DBV0006A; MPN SN74LVC1G11DBVR
PV_U5: SN74LVC1G74DCTR; TI_DCT0008A; MPN SN74LVC1G74DCTR
PV_U6: TPS37042BJOFDDFRQ1; TI_DDF0008A_SOT-23-8_1.6x2.9mm_P0.65mm; MPN TPS37042BJOFDDFRQ1
R27: 1 mOhm / Kelvin; Bourns_CSS4J_4026R_1L00F_Kelvin; MPN CSS4J-4026R-1L00F
U2: INA241A3IDDFR; TI_DDF0008A_SOT-23-8_1.6x2.9mm_P0.65mm; MPN INA241A3IDDFR

Connections:
GND: C22.2, PV_C103.2, PV_C104.2, PV_C105.2, PV_C106.2, PV_C107.2, PV_C108.2, PV_C_PV_U3.2, PV_C_PV_U4.2, PV_C_PV_U5.2, PV_D104.1 (A), PV_D104.2 (A), PV_D105.1 (A), PV_D105.2 (A), PV_R102.2, PV_R107.2, PV_R109.2, PV_R110.2, PV_R112.2, PV_R113.2, PV_R114.2, PV_R116.2, PV_R117.2, PV_R_SUP26.2, PV_R_SUP32.2, PV_U1.9 (ISET), PV_U1.17 (GND), PV_U3.2 (GND), PV_U4.2 (GND), PV_U5.4 (GND), PV_U6.4 (GND), U2.2 (GND), U2.3 (REF2), U2.4 (GND); also elsewhere on the board
IPV_OUT: PV_U3.3 (IN+), U2.5; also elsewhere on the board
PV_AFTER_SHUNT: L2.1, PV_D102.K, PV_R103.1, R27.IM, R27.KM, U2.1 (-)
PV_BOOTSTRAP: PV_C102.1, PV_D101.3 (K), PV_U1.14 (BST)
PV_CMP_OUT: PV_U3.1 (OUT), PV_U4.1
PV_CMP_REF: PV_C103.1, PV_R111.2, PV_R112.1, PV_U3.4 (IN-)
PV_DRIVER_OVLO: PV_R108.2, PV_R109.1, PV_U1.8 (OVLO)
PV_DRIVER_RUN: PV_R115.2, PV_R116.1, PV_U1.1 (RUN)
PV_DRIVER_TGUP: PV_R105.1, PV_U1.12 (TGUP)
PV_DRIVER_TIMER: PV_C104.1, PV_R114.1, PV_U1.6 (TIMER)
PV_DRIVER_VCC: PV_C105.1, PV_D101.1 (A), PV_U1.3 (VCC)
PV_FET_GATE: PV_D103.1 (K), PV_Q1.1 (G), PV_Q2.1 (G), PV_R105.2, PV_R106.1, PV_R118.1, PV_U1.11 (TGDN)
PV_FET_SOURCE: PV_C102.2, PV_D103.2 (A), PV_D105.K, PV_Q1.3 (S), PV_Q2.3 (S), PV_R106.2, PV_U1.13 (TS)
PV_FUSED: PV_C106.1, PV_R108.1, PV_R115.1, PV_U1.2 (VIN), PV_U1.16 (SNS+), R27.IP, R27.KP, U2.8 (+); also elsewhere on the board
PV_GATE_RC: PV_C107.1, PV_R118.2
PV_L2_OUT: L2.2, PV_D102.1 (A), PV_D102.2 (A), PV_D104.K, PV_Q1.2 (D)
PV_LATCH_CLR_N: PV_U4.4, PV_U5.6 (~CLR)
PV_LATCH_Q: PV_R107.1, PV_U1.7 (INP), PV_U5.5 (Q)
PV_MCU_REARM: PV_R110.1, PV_U5.1 (CLK); also elsewhere on the board
PV_MCU_RUN: PV_R113.1, PV_U4.6; also elsewhere on the board
PV_OC_FAULT_N: PV_R104.2, PV_U1.5 (FAULT_N); also elsewhere on the board
PV_REF2V5_SENSE: PV_R_SUP25.2, PV_R_SUP26.1, PV_U6.3 (SENSE2)
PV_SNS_MINUS: PV_R103.2, PV_U1.15 (SNS-)
PV_STOPPED: PV_U5.3 (~Q); also elsewhere on the board
PV_SUP_RESET_N: PV_R102.1, PV_R119.2, PV_U4.3, PV_U6.7 (RESET2_N), PV_U6.8 (RESET1_N)
PV_V3V3_SENSE: PV_R_SUP31.2, PV_R_SUP32.1, PV_U6.2 (SENSE1)
PV_VCCUV: PV_R117.1, PV_U1.4 (VCCUV)
V3V3: C22.1, PV_C108.1, PV_C_PV_U3.1, PV_C_PV_U4.1, PV_C_PV_U5.1, PV_R104.1, PV_R119.1, PV_R_SUP31.1, PV_U3.5 (VCC), PV_U4.5 (VCC), PV_U5.2 (D), PV_U5.7 (~PRE), PV_U5.8 (VCC), PV_U6.1 (VDD), U2.6 (V+); also elsewhere on the board
VIN: PV_Q2.2 (D); also elsewhere on the board
VREF2V5_ADC: PV_R111.1, PV_R_SUP25.1, U2.7 (REF1); also elsewhere on the board

Notes on the sheet:
ERC: PV_FUSED supplied from PV strings via F2.
供給元：親シートのPV入力とF2（旗も同位置）

Board: 6 copper layers, 264.0 x 136.0 mm, 191 parts (37 on the bottom side), 102 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3
